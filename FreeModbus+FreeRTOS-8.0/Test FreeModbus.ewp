# IAR project Test FreeModbus.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103RC ST STM32F103RC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_MD
  ICCARM.CCIncludePath2: CMSIS; StdPeriph_Driver\inc; User; my code\12864; my code\delay; my code\key; my code\LED; my code\Agreement\FreeModbus\modbus; my code\Agreement\FreeModbus\modbus\include; my code\Agreement\FreeModbus\port; my code\Agreement\FreeModbus\modbus\rtu; my code\Agreement\FreeModbus\modbus\ascii; my code\system\FreeRTOS-8\portable\IAR\ARM_CM3; my code\system\FreeRTOS-8\include; my code\system\FreeRTOS-8; my code\Agreement\FreeModbus\Executable; my code\system\System task; my code\STMFLASH
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: User; my code\system\FreeRTOS-8\portable\IAR\ARM_CM3
  OBJCOPY.OOCOutputFile: Test FreeModbus.bin
  ILINK.IlinkOutputFile: Test FreeModbus.out
  ILINK.IlinkIcfFile: Linker\stm32f10x_flash
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCIncludePath2: CMSIS; StdPeriph_Driver\inc; User; my code\12864; my code\delay; my code\key; my code\LED; my code\Agreement\FreeModbus\modbus; my code\Agreement\FreeModbus\modbus\include; my code\Agreement\FreeModbus\port; my code\Agreement\FreeModbus\modbus\rtu; my code\Agreement\FreeModbus\modbus\ascii; my code\system\FreeRTOS-8\portable\IAR\ARM_CM3; my code\system\FreeRTOS-8\include; my code\system\FreeRTOS-8; my code\Agreement\FreeModbus\Executable; my code\system\System task
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: Test FreeModbus.srec
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\ST\stm32f103xC.icf
  group CMSIS
    CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FreeModbus/Executable
    my code/Agreement/FreeModbus/Executable/: Executable.C
  group FreeModbus/modbus
    my code/Agreement/FreeModbus/modbus/: mb.c
    my code/Agreement/FreeModbus/modbus/ascii/: mbascii.c
  group FreeModbus/modbus/functions
    my code/Agreement/FreeModbus/modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
  group FreeModbus/modbus/include
    my code/Agreement/FreeModbus/modbus/include/: mb.h mbconfig.h mbframe.h mbfunc.h mbport.h mbproto.h mbutils.h
    my code/Agreement/FreeModbus/modbus/ascii/: mbascii.h
  group FreeModbus/modbus/RTU
    my code/Agreement/FreeModbus/modbus/rtu/: mbcrc.c mbcrc.h mbrtu.c mbrtu.h
  group FreeModbus/port
    my code/Agreement/FreeModbus/port/: port.h portevent.c portserial.c porttimer.c
  group FreeRTOS_Ports
    my code/system/FreeRTOS-8/portable/MemMang/: heap_4.c
    my code/system/FreeRTOS-8/portable/IAR/ARM_CM3/: port.c portasm.s portmacro.h
  group FreeRTOS_Ports/System task
    my code/system/System task/: Systemtask.c
  group FreeRTOS_Source
    my code/system/FreeRTOS-8/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group my code
    my code/delay/: delay.c
    my code/key/: key.c
    my code/LED/: led.c
    my code/12864/: OLED.C
    my code/STMFLASH/: stmflash.c
  group StartUp
    StartUp/: startup_stm32f10x_hd.s startup_stm32f10x_md.s
  group StdPeriph_Driver
    StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group User
    User/: FreeRTOSConfig.h includes.h main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group 说明
    说明/: 说明.txt
